FILESEXTRAPATHS:prepend := "${THISDIR}/files/:"

# Patches disabled - may need updating for latest master
#SRC_URI += " file://mediastreamer2_cmakefile.patch"
