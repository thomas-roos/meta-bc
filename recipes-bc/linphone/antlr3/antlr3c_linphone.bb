require antlr3c.inc

PR = "${INC_PR}.0"

SRCREV = "ac1069cf214b15b86272cbc6ded5916d7d2f85ec"
SRC_URI = "git://gitlab.linphone.org/BC/public/external/antlr3.git;protocol=https;nobranch=1"
PV = "git_${SRCREV}"

LIC_FILES_CHKSUM = "file://COPYING;md5=13c502aaa9b2ca91d01a3aae44d899b4"
